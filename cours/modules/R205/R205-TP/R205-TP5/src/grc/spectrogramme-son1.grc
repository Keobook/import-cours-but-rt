options:
  parameters:
    author: Philippe PUJAS
    generate_options: qt_gui
    id: spectrogramme_son
    output_language: python
    title: Spectrogramme d'un son
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/test/Musique/32768.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    freqhalf: 'False'
    tr_level: '-60'
    type: float
    update_time: '0.1'
    wintype: window.WIN_BLACKMAN
  states: {}

connections:
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
